# Keil uVision project MinSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MinSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Program Files (x86)\Keil_v5\C51\INC
  group src
    ./: STARTUP.A51 test.c clock.c show.c timer.c
  group inc
    ./: show.h clock.h timer.h
